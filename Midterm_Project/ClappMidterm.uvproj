# Keil uVision project ClappMidterm.uvproj, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: LPC1114/202 NXP
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: ClappMidterm
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group Source Group 1
    ./: startup_LPC11xx.s LPC11xx.inc main.s Keypad_init.s LCD_command.s LCD_init.s Divide.s Constants.inc BusyWait.s ConfigClock.s print_string.s LCD_config_dir.s Keypad_config_dir.s EnableP0Interrupt.s DisableP0Interrupt.s Key_num_to_ascii.s PIOINT0_IRQHandler.s wait_for_key_release.s get_key_num.s get_next_key_input.s clear_new_key_flag.s Print_Character.s EnterTx.s memorySearch.s print_decimal_to_LCD.s enterChannel.s configureChannel.s channel_init.s Init_TMR32B0.s Init_TMR32B1.s Init_TMR16B0.s Init_TMR16B1.s determine_prescale.s processInputs.s memory_update.s capture_init.s TIMER32_0_IRQHandler.s capture_flag_handler.s GlobalVariables.inc TMR32B0MR3_Interrupt.s

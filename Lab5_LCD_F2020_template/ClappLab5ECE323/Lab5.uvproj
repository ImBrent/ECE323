# Keil uVision project Lab5.uvproj, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: LPC1114/102 NXP
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Lab5
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group Source Group 1
    ./: startup_LPC11xx.s LPC11xx.inc Lab5.s BusyWait.s LCD_command.s LCD_init.s print_string.s ConfigDir.s ConfigInit.s Level1.s Level2.s Level2_print_string.s Level3.s string_length.s Level3_print_string.s
